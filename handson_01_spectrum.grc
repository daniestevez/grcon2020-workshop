options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: handson_01_spectrum
    output_language: python
    title: 'GRCon20 workshop hands-on: visualizing the spectrum'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2016129'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: recordings/solarorbiter-8427070000Hz_20200213_164325.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    type: complex
    ymax: '-65'
    ymin: '-110'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.1.1-58-g637fcda4
