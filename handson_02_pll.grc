options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: handson_02_pll
    output_language: python
    title: 'GRCon20 workshop hands-on: carrier phase locking with a PLL'
  states: {}

blocks:
- name: pll_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2016129'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2 * pi * pll_limit / samp_rate
    min_freq: '-2 * pi * pll_limit / samp_rate'
    w: 2 * pi * pll_bw / samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: recordings/solarorbiter-8427070000Hz_20200213_164325.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: PLL input
    label2: PLL output
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-15'
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: I
    label2: Q
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-15'
    ymin: '-60'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-4'
    reference: '1.0'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', satellites_rms_agc_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
