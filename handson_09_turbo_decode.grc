options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: handson_09_turbo_decode
    output_language: python
    title: 'GRCon20 workshop hands-on: Turbo decoding'
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2016129'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '555555'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''034776C7272895B0'''
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2 * pi * pll_limit / samp_rate
    min_freq: '-2 * pi * pll_limit / samp_rate'
    w: 2 * pi * pll_bw / samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 555.555e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: frames.u8
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: recordings/solarorbiter-8427070000Hz_20200213_164325.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code
    tagname: syncword
    threshold: '4'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code
    tagname: syncword
    threshold: '4'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '2'
    octets: '5'
    sigma: '0.707'
    update_sigma: '1'
  states: {}
- name: dslwp_frame_spliter_f_0
  id: dslwp_frame_spliter_f
  parameters:
    frame_length: '17848'
    key: syncword
  states: {}
- name: dslwp_frame_spliter_f_0_0
  id: dslwp_frame_spliter_f
  parameters:
    frame_length: '17848'
    key: syncword
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.ones(int(sps))/int(sps) / 1.57
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    nconnections: '2'
    size: '100000'
    srate: symbol_rate
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-4'
    reference: '1.0'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_arg_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_complex_to_arg_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_complex_to_real_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', satellites_rms_agc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_correlate_access_code_tag_xx_0, '0', dslwp_frame_spliter_f_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', dslwp_frame_spliter_f_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_turbo_decode_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [dslwp_frame_spliter_f_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [dslwp_frame_spliter_f_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [hilbert_fc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']

metadata:
  file_format: 1
